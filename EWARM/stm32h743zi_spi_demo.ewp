# IAR project stm32h743zi_spi_demo.ewp, settings and files
configuration stm32h743zi_spi_demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32h743zi_spi_demo.hex
  ILINK.IlinkOutputFile: stm32h743zi_spi_demo.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: debug.c gpio.c main.c spi.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
