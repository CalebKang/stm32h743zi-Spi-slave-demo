<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32h743zi_spi_demo.ewp</path>
  </project>
  <batchBuild />
</workspace>
